# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\HAREWARE\KEY;..\HAREWARE\LED;..\HAREWARE\TIMER;..\HAREWARE\Global;..\HAREWARE\USART;..\HAREWARE\DELAY;..\HAREWARE\OLED;..\HAREWARE\USART3;..\HAREWARE\ENCODING;..\HAREWARE\DECODING
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/LED/: led.c
    ../HAREWARE/TIMER/: timer.c
    ../HAREWARE/USART/: usart.c
    ../HAREWARE/DELAY/: delay.c
    ../HAREWARE/OLED/: oled.c
    ../HAREWARE/USART3/: usart3.c
    ../HAREWARE/ENCODING/: encoding.c
    ../HAREWARE/DECODING/: decoding.c
